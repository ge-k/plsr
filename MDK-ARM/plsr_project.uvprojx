# Keil uVision project plsr_project.uvprojx, settings and files
target plsr_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: plsr_project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MyDrivers;../MyDrivers/motor_driver;../MyDrivers/usart_driver;../MyDrivers/flash_driver;../MyTask;../MyAPP;../Component/modbus;../Component/plsr
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group MyDrivers
    ../MyDrivers/: my_define.h
    ../MyDrivers/flash_driver/: flash_driver.c flash_driver.h
    ../MyDrivers/usart_driver/: usart_driver.c usart_driver.h
    ../MyDrivers/motor_driver/: plsr_board.h plsr_hw.c plsr_hw.h
  group MyTask
    ../MyTask/: motor_task.c motor_task.h usart_task.c usart_task.h vofa_app.c vofa_app.h
  group MyApp
    ../MyAPP/: my_main.c my_main.h scheduler.c scheduler.h
  group Component/modbus
    ../Component/modbus/: agile_modbus.c agile_modbus.h agile_modbus_rtu.c agile_modbus_rtu.h agile_modbus_slave_util.c agile_modbus_slave_util.h modbus_app.c modbus_app.h
  group Component/plsr
    ../Component/plsr/: plsr_types.h plsr_config.c plsr_config.h plsr_profile.c plsr_profile.h plsr_core.c plsr_core.h plsr_storage.c plsr_storage.h plsr_port.c plsr_port.h plsr_service.c plsr_service.h
software components: CMSIS:CORE 4.3.0
